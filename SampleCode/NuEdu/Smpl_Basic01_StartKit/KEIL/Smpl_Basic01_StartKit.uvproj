# Keil uVision project Smpl_Basic01_StartKit.uvproj, settings and files
target Smpl_Basic01_StartKit (6160000::V6.16::ARMCLANG)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: Smpl_Basic01_StartKit
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\NuEdu\inc;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: spi.c i2c.c retarget.c gpio.c clk.c sys.c uart.c eadc.c pwm.c
  group NuEdu
    ../../../../Library/NuEdu/src/: NuEdu-Basic01_7_Segment.c NuEdu-Basic01_Button.c NuEdu-Basic01_RGBLED.c NuEdu-Basic01_ADC_Knob.c NuEdu-Basic01_Buzzer.c NuEdu-Basic01_LED.c NuEdu-Basic01_SPI_Flash.c NuEdu-Basic01_EEPROM.c NuEdu-Basic01_IrDA_NEC.c

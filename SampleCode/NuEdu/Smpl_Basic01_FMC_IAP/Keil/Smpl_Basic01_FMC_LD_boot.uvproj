# Keil uVision project Smpl_Basic01_FMC_LD_boot.uvproj, settings and files
target fmc_ld_boot (6190000::V6.19::ARMCLANG)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: fmc_ld_boot
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\NuEdu\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group Libraries
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c fmc.c
  group User
    ../: ld_boot.c

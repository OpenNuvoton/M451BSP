# Keil uVision project RTOSDemo.uvproj, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOSDemo +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group System
    ../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group Demo Files
    ../: main.c ParTest.c
    ../../../ThirdParty/FreeRTOS/DEMO/COMMON/Minimal/: QueueSet.c flash.c PollQ.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/SOURCE/: tasks.c timers.c list.c queue.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/RVDS/ARM_CM4F/: port.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/MemMang/: heap_2.c
  group lib
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c

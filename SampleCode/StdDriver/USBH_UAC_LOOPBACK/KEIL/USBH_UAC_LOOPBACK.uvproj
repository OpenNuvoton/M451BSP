# Keil uVision project USBH_UAC_LOOPBACK.uvproj, settings and files
target USBH_UAC_LOOPBACK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: USBH_UAC_LOOPBACK
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\..\Library\UsbHostLib\INCLUDE
  asm define: Stack_Size=0x1000, Heap_Size=0x1000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ../: main.c uac_loopback.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c spi.c i2c.c timer.c gpio.c uart.c
  group USBH_Core_Lib
    ../../../../Library/UsbHostLib/SOURCE/Core/: usbh_core.c usbh_debug.c usbh_hub.c usbh_ohci.c usbh_support.c
  group USBH_UAC_Lib
    ../../../../Library/UsbHostLib/SOURCE/AudioClass/: uac_core.c uac_driver.c uac_parser.c

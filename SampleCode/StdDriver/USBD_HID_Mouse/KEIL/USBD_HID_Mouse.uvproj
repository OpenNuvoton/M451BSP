# Keil uVision project USBD_HID_Mouse.uvproj, settings and files
target USBD_HID_Mouse (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: USBD_HID_Mouse
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M451Series\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ../: descriptors.c main.c hid_mouse.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c sys.c clk.c uart.c

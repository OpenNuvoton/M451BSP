# IAR project USBH_UAC_HID.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M451AE series Nuvoton M451AE series (M451AE,M452AE,M453AE,M451MAE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M451Series\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_UAC_HID.bin
  ILINK.IlinkOutputFile: USBH_UAC_HID.out
  ILINK.IlinkIcfFile: USBH_UAC_HID.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/IAR/: startup_M451Series.s
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c uart.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: hub.c mem_alloc.c ohci.c usb_core.c
  group UsbHostLib_HID
    ../../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c
  group UsbHostLib_UAC
    ../../../../Library/UsbHostLib/src_uac/: uac_core.c uac_driver.c uac_parser.c
  group User
    ../: main.c
